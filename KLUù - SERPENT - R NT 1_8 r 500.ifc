Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: efbc4303-9953-4731-8e7d-e52e77dfc4e5, NumberOfSaves: 16], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Internal]
File name: Project Number
Time: 2023-11-29T13:33:58+01:00
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.2.0.63 (ENU) - IFC 24.1.1.6

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 0; sets with these values: 2
Other - Category: Levels; Family: Level; Family and Type: Level: Circle Head - Project Datum; Type: Circle Head - Project Datum; Type Id: 305
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 0; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle : Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no
Identity Data(Type) - Type Name: Circle Head - Project Datum

# IfcDistributionPort, Port_350854_1
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcFlowTerminal: KLUŚ - SERPENT - R NT 1_8 r 500:Silver Anodized - 4000 K - 640 lm, KLUŚ - SERPENT - R NT 1_8 r 500:Silver Anodized - 4000 K - 640 lm:350854
In: Level 0
Type - Material: Steel, Aluminum, Silver Anodized, PC - 4000 K
Type - Other - Category: Lighting Fixtures; Color: silver anodized; Control: ON/OFF; Cover: frosted; Dimensions L x W x H: 187 x 370 x 88; Family Name: KLUŚ - SERPENT - R NT 1_8 r 500; Lighting direction: down; Material: aluminum; Mounting type: surface mounted; Shape: 1/8 r 500
Type - Constraints - Default Elevation: 0 mm
Type - Data - Color rendering index: 90 CRI; Color temperature: 4000 K; Efficiency: 64 lm/W; IP protection rating: IP20; Luminare power: 10 W; Luminous flux of the fixture: 640 lm; MacAdam’s ellipse: 3 SDCM; Protection class: I; Supply voltage: 220-240 V 50/60 Hz
Type - Dimensions - Light Source Symbol Size: 5 mm
Type - Electrical - Loads - Apparent Load: 10 W; Input voltage: 240 V; Power consumption: 10 W; Power factor: 1
Type - General - OmniClassCode: 23.80.70.11.14.11; OmniClassTitle: Downlights; Uniclass2015Code: Pr_70_70_48_24; Uniclass2015Title: Downlights; Uniclass2015Version: Products v1.31
Type - Identity Data - Author: www.archispace.pl; Manufacturer: KLUŚ Sp. z o.o.; Model: R NT 1/8 r 500; OmniClass Number: 23.80.70.11.14.11; OmniClass Title: Downlights; Ref No: FNSE057-0140EB; System: SERPENT; Type Name: Silver Anodized - 4000 K - 640 lm; URL: https://klusdesign.eu/en
Type - Photometrics - Color Filter: 16777215; Dimming Lamp Color Temperature Shift: <None>; Efficacy: 148.542 s3*lm/kg/m2; Emit from Rectangle Length: 365 mm; Emit from Rectangle Width: 180 mm; Emit Shape Visible in Rendering: no; Illuminance: 54.8201 lx; Initial Color Temperature: 4000 K; Light Source Definition (family): Rectangle+HemiSpherical; Luminous Flux: 640 lm; Luminous Intensity: 509.296 cd; Total Light Loss Factor: 1; Wattage: 10.7714 W
Type - Materials and Finishes - Body material: Aluminum, Silver Anodized; Diffuser material: PC - 4000 K
Type - Pset_ElementShading - Color: silver anodized
Type - Pset_ManufacturerTypeInformation - Manufacturer: KLUŚ Sp. z o.o.
Pset_DistributionFlowElementCommon - Reference: KLUŚ - SERPENT - R NT 1_8 r 500:Silver Anodized - 4000 K - 640 lm; sets with these values: 2
Other - Family: KLUŚ - SERPENT - R NT 1_8 r 500; Family and Type: KLUŚ - SERPENT - R NT 1_8 r 500: Silver Anodized - 4000 K - 640 lm; Type: Silver Anodized - 4000 K - 640 lm; Type Id: 350747
Model Properties - Connector n: 3
Constraints - Elevation from Level: 93 mm; Host: Reference Plane; Level: Level 0; Schedule Level: Level 0
Construction - Plug left: yes; Plug right: yes; Power cable: yes
Dimensions - Area: 0.13634 m2; Volume: 0.00185798 m3
Electrical - Circuiting - Electrical Data: 220-240 V 50/60 Hz 240 V/1-10 VA
Electrical - Lighting - Calculate Coefficient of Utilization: no
Identity Data - Mark: 20
Phasing - Phase Created: New Construction
